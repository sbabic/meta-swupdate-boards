PACKAGECONFIG:append = " networkd resolved"
