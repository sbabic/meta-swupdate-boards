FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append_wandboard = "file://wandboard_env_redund.patch"
