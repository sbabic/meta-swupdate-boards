FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

COMPATIBLE = "raspberrypi3 raspberrypi4-64"
